# Keil uVision project STMcode.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STMcode
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c ui.c ui.h com.c com.h control.c control.h startup_stm32f303xe.s stm32f303xe.h SysClock.c SysClock.h system_stm32f3xx.c uart.c uart.h stm32f3xx.h system_stm32f3xx.h bitwise.h bitwise.c stylus.c stylus.h tilt.c tilt.h pwm.c pwm.h spi.c spi.h i2c.c i2c.h main.h
software components: CMSIS:CORE 6.1.0
